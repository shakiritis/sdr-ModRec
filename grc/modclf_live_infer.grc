options:
  parameters:
    author: shakir
    generate_options: qt_gui
    id: modclf_live_infer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cfo_hz
  id: variable_qtgui_range
  parameters:
    label: CFO (Hz)
    start: '-2000'
    step: '50'
    stop: '2000'
    value: '0'
  states: {state: disabled}
- name: cfo_hz
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cfo_norm
  id: variable
  parameters:
    value: cfo_hz / samp_rate
  states: {}
- name: mod_sel
  id: variable_qtgui_chooser
  parameters:
    label: Modulation
    label0: '"BPSK"'
    label1: '"QPSK"'
    label2: '"8PSK"'
    label3: '"16QAM"'
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: (0.5 * 10**(-snr_db/10.0))**0.5
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '-5'
    step: '1'
    stop: '25'
    value: '20'
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '3'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '7'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '15'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_sel
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: cfo_norm
    noise_voltage: noise_volt
    seed: '0'
    taps: '[1.0+0j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: complex
    symbol_table: '[(1+1j)/np.sqrt(2), (-1+1j)/np.sqrt(2), (-1-1j)/np.sqrt(2), (1-1j)/np.sqrt(2)]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: complex
    symbol_table: '[np.exp(1j*2*np.pi*k/8) for k in range(8)]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: complex
    symbol_table: '[(i+1j*q)/np.sqrt(10) for q in [-3,-1,1,3] for i in [-3,-1,1,3]]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport onnxruntime as ort\nimport json\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self, model_path=\"models/modclf.onnx\", labels_path=\"models/labels.json\",\n                 win_len=1024, hop_len=256, print_on_change=True):\n        gr.sync_block.__init__(\n            self,\n            name=\"modclf_infer_onnx\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64, np.float32],\n        )\n\n        self.message_port_register_out(pmt.intern(\"label_out\"))\n\n        self.win_len = int(win_len)\n        self.hop_len = int(hop_len)\n        self.print_on_change = bool(print_on_change)\n\n        with open(labels_path, \"r\") as f:\n            self.labels = json.load(f)\n\n        sess_opts = ort.SessionOptions()\n        sess_opts.intra_op_num_threads = 1\n        self.sess = ort.InferenceSession(model_path, sess_options=sess_opts, providers=[\"CPUExecutionProvider\"])\n        self.input_name = self.sess.get_inputs()[0].name\n\n        self.buf = np.zeros(self.win_len, dtype=np.complex64)\n        self.fill = 0\n        self.last_pred = -1\n        self.current_pred = 0.0\n\n    def _preprocess(self, x_cplx):\n        # RMS normalize in float64 (safe)\n        mag2 = (np.real(x_cplx).astype(np.float64)**2 + np.imag(x_cplx).astype(np.float64)**2)\n        p = np.mean(mag2)\n        if (not np.isfinite(p)) or p < 1e-18:\n            return None\n        x = x_cplx / np.float32(np.sqrt(p))\n\n        I = np.real(x).astype(np.float32)\n        Q = np.imag(x).astype(np.float32)\n        X = np.stack([I, Q], axis=0)[None, :, :]  # (1,2,L)\n        return X\n\n    def _infer(self, x_cplx):\n        X = self._preprocess(x_cplx)\n        if X is None:\n            return None\n        logits = self.sess.run(None, {self.input_name: X})[0]  # (1,C)\n        return int(np.argmax(logits, axis=1)[0])\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        y = output_items[0]     # complex passthrough\n        ylab = output_items[1]  # float label index\n\n        y[:] = x\n        ylab[:] = self.current_pred  # hold last prediction\n\n        n = len(x)\n        i = 0\n        while i < n:\n            take = min(n - i, self.win_len - self.fill)\n            self.buf[self.fill:self.fill+take] = x[i:i+take]\n            self.fill += take\n            i += take\n\n            if self.fill == self.win_len:\n                pred = self._infer(self.buf)\n                if pred is not None:\n                    self.current_pred = float(pred)\n\n                    if pred != self.last_pred:\n                        label = self.labels[pred]\n#                        self.add_item_tag(1, self.nitems_written(1), pmt.intern(\"mod\"), pmt.intern(label))\n                        if self.print_on_change:\n                            print(\"[modclf] predicted:\", label)\n                        self.message_port_pub(pmt.intern(\"label_out\"), pmt.intern(label))\n                        self.last_pred = pred\n\n                # overlap shift\n                hop = self.hop_len\n                self.buf[:self.win_len-hop] = self.buf[hop:]\n                self.fill = self.win_len - hop\n\n        return n\n\n"
    hop_len: '256'
    labels_path: '"/media/shakir/EXT4_1TB/projects/sdr/modclf-gnuradio-ml/models/labels.json"'
    model_path: '"/media/shakir/EXT4_1TB/projects/sdr/modclf-gnuradio-ml/models/modclf.onnx"'
    print_on_change: 'True'
    win_len: '1024'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport onnxruntime as ort\nimport json\nimport pmt\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Predict modulation once every update_period_s seconds (time-based),\n    using the last win_len samples from a ring buffer.\n    \"\"\"\n\n    def __init__(self,\n                 model_path=\"models/modclf.onnx\",\n                 labels_path=\"models/labels.json\",\n                 win_len=1024,\n                 samp_rate=1e6,\n                 update_period_s=1.0,\n                 print_on_change=True):\n        gr.sync_block.__init__(\n            self,\n            name=\"modclf_infer_onnx_1hz\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64, np.float32],\n        )\n\n        self.message_port_register_out(pmt.intern(\"label_out\"))\n\n        self.win_len = int(win_len)\n        self.samp_rate = float(samp_rate)\n        self.update_period_s = float(update_period_s)\n        self.print_on_change = bool(print_on_change)\n\n        self.samples_per_update = max(1, int(round(self.samp_rate * self.update_period_s)))\n        self.samples_since_update = 0\n\n        with open(labels_path, \"r\") as f:\n            self.labels = json.load(f)\n\n        sess_opts = ort.SessionOptions()\n        sess_opts.intra_op_num_threads = 1\n        self.sess = ort.InferenceSession(model_path, sess_options=sess_opts, providers=[\"CPUExecutionProvider\"])\n        self.input_name = self.sess.get_inputs()[0].name\n\n        self.buf = np.zeros(self.win_len, dtype=np.complex64)\n        self.widx = 0\n        self.filled = 0\n\n        self.current_pred = 0.0\n        self.last_pred = -1\n\n    def _preprocess(self, x_cplx):\n        re = np.real(x_cplx).astype(np.float64)\n        im = np.imag(x_cplx).astype(np.float64)\n        p = np.mean(re*re + im*im)\n        if (not np.isfinite(p)) or p < 1e-18:\n            return None\n        x = x_cplx / np.float32(np.sqrt(p))\n\n        I = np.real(x).astype(np.float32)\n        Q = np.imag(x).astype(np.float32)\n        X = np.stack([I, Q], axis=0)[None, :, :]  # (1,2,L)\n        return X\n\n    def _infer_from_buffer(self):\n        if self.filled < self.win_len:\n            return None\n\n        # last win_len samples in time order\n        if self.widx == 0:\n            window = self.buf.copy()\n        else:\n            window = np.concatenate((self.buf[self.widx:], self.buf[:self.widx])).astype(np.complex64, copy=False)\n\n        X = self._preprocess(window)\n        if X is None:\n            return None\n\n        logits = self.sess.run(None, {self.input_name: X})[0]  # (1,C)\n        return int(np.argmax(logits, axis=1)[0])\n\n    def _write_ring(self, x):\n        n = len(x)\n        if n == 0:\n            return\n\n        # IMPORTANT FIX: if GNU Radio gives us >= win_len samples in one call,\n        # just keep the last win_len samples.\n        if n >= self.win_len:\n            tail = x[-self.win_len:].astype(np.complex64, copy=False)\n            self.buf[:] = tail\n            self.widx = 0\n            self.filled = self.win_len\n            return\n\n        end = self.widx + n\n        if end <= self.win_len:\n            self.buf[self.widx:end] = x\n        else:\n            first = self.win_len - self.widx\n            self.buf[self.widx:] = x[:first]\n            second = end % self.win_len\n            if second > 0:\n                self.buf[:second] = x[first:first+second]\n\n        self.widx = end % self.win_len\n        self.filled = min(self.win_len, self.filled + n)\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        y = output_items[0]\n        ylab = output_items[1]\n\n        y[:] = x\n        ylab[:] = self.current_pred\n\n        self._write_ring(x)\n        self.samples_since_update += len(x)\n\n        # run at most once per work() call (keeps GUI smooth)\n        if self.filled >= self.win_len and self.samples_since_update >= self.samples_per_update:\n            pred = self._infer_from_buffer()\n            if pred is not None:\n                self.current_pred = float(pred)\n                if pred != self.last_pred:\n                    label = self.labels[pred]\n                    if self.print_on_change:\n                        print(\"[modclf] predicted:\", label)\n                    self.message_port_pub(pmt.intern(\"label_out\"), pmt.intern(label))\n                    self.last_pred = pred\n\n            self.samples_since_update -= self.samples_per_update\n\n        return len(x)\n\n"
    labels_path: '"/media/shakir/EXT4_1TB/projects/sdr/modclf-gnuradio-ml/models/labels.json"'
    model_path: '"/media/shakir/EXT4_1TB/projects/sdr/modclf-gnuradio-ml/models/modclf.onnx"'
    print_on_change: 'True'
    samp_rate: samp_rate
    update_period_s: '1.0'
    win_len: '1024'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport onnxruntime as ort\nimport json\nimport pmt\nfrom gnuradio import gr\n\nfrom PyQt5 import QtWidgets, QtCore\n\nclass LabelPopup(QtWidgets.QWidget):\n    def __init__(self, title=\"Modulation Prediction\"):\n        super().__init__()\n        self.setWindowTitle(title)\n        self.setMinimumSize(420, 160)\n\n        self.label = QtWidgets.QLabel(\"...\", self)\n        self.label.setAlignment(QtCore.Qt.AlignCenter)\n\n        font = self.label.font()\n        font.setPointSize(28)\n        font.setBold(True)\n        self.label.setFont(font)\n\n        layout = QtWidgets.QVBoxLayout()\n        layout.addWidget(self.label)\n        self.setLayout(layout)\n\n    @QtCore.pyqtSlot(str)\n    def set_text(self, text):\n        self.label.setText(text)\n\nclass blk(gr.sync_block):\n    def __init__(self,\n                 model_path=\"models/modclf.onnx\",\n                 labels_path=\"models/labels.json\",\n                 win_len=1024,\n                 hop_len=256,\n                 print_on_change=True,\n                 enable_label_out=True,\n                 enable_popup=True,\n                 popup_title=\"Modulation Prediction\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"modclf_infer_onnx\",\n            in_sig=[np.complex64],\n            out_sig=[np.float32],   # ONLY label index output\n        )\n\n        # Optional message port\n        self.enable_label_out = bool(enable_label_out)\n        if self.enable_label_out:\n            self.message_port_register_out(pmt.intern(\"label_out\"))\n\n        self.win_len = int(win_len)\n        self.hop_len = int(hop_len)\n        self.print_on_change = bool(print_on_change)\n\n        with open(labels_path, \"r\") as f:\n            self.labels = json.load(f)\n\n        sess_opts = ort.SessionOptions()\n        sess_opts.intra_op_num_threads = 1\n        self.sess = ort.InferenceSession(\n            model_path,\n            sess_options=sess_opts,\n            providers=[\"CPUExecutionProvider\"]\n        )\n        self.input_name = self.sess.get_inputs()[0].name\n\n        self.buf = np.zeros(self.win_len, dtype=np.complex64)\n        self.fill = 0\n        self.last_pred = -1\n        self.current_pred = 0.0\n\n        # Popup\n        self._popup = None\n        self.enable_popup = bool(enable_popup)\n        if self.enable_popup:\n            app = QtWidgets.QApplication.instance()\n            if app is not None:\n                self._popup = LabelPopup(title=str(popup_title))\n                self._popup.show()\n\n    def _preprocess(self, x_cplx):\n        mag2 = (np.real(x_cplx).astype(np.float64)**2 + np.imag(x_cplx).astype(np.float64)**2)\n        p = np.mean(mag2)\n        if (not np.isfinite(p)) or p < 1e-18:\n            return None\n        x = x_cplx / np.float32(np.sqrt(p))\n\n        I = np.real(x).astype(np.float32)\n        Q = np.imag(x).astype(np.float32)\n        X = np.stack([I, Q], axis=0)[None, :, :]  # (1,2,L)\n        return X\n\n    def _infer(self, x_cplx):\n        X = self._preprocess(x_cplx)\n        if X is None:\n            return None\n        logits = self.sess.run(None, {self.input_name: X})[0]  # (1,C)\n        return int(np.argmax(logits, axis=1)[0])\n\n    def _popup_set_label(self, label):\n        if self._popup is not None:\n            QtCore.QMetaObject.invokeMethod(\n                self._popup,\n                \"set_text\",\n                QtCore.Qt.QueuedConnection,\n                QtCore.Q_ARG(str, str(label))\n            )\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        ylab = output_items[0]  # float label index output\n\n        # hold last prediction across samples\n        ylab[:] = self.current_pred\n\n        n = len(x)\n        i = 0\n        while i < n:\n            take = min(n - i, self.win_len - self.fill)\n            self.buf[self.fill:self.fill+take] = x[i:i+take]\n            self.fill += take\n            i += take\n\n            if self.fill == self.win_len:\n                pred = self._infer(self.buf)\n                if pred is not None:\n                    self.current_pred = float(pred)\n\n                    if pred != self.last_pred:\n                        label = self.labels[pred]\n\n                        if self.print_on_change:\n                            print(\"[modclf] predicted:\", label)\n\n                        self._popup_set_label(label)\n\n                        if self.enable_label_out:\n                            self.message_port_pub(pmt.intern(\"label_out\"), pmt.intern(label))\n\n                        self.last_pred = pred\n\n                # overlap shift\n                hop = self.hop_len\n                self.buf[:self.win_len-hop] = self.buf[hop:]\n                self.fill = self.win_len - hop\n\n        return n\n\n"
    enable_label_out: 'True'
    enable_popup: 'True'
    hop_len: '256'
    labels_path: '"/media/shakir/EXT4_1TB/projects/sdr/sdr-ModRec/models/labels.json"'
    model_path: '"/media/shakir/EXT4_1TB/projects/sdr/sdr-ModRec/models/modclf.onnx"'
    popup_title: '"Predicted Modulation"'
    print_on_change: 'True'
    win_len: '1024'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: |
      firdes.root_raised_cosine(1.0, samp_rate, samp_rate/sps, rolloff, span*sps)
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: |
      firdes.root_raised_cosine(1.0, samp_rate, samp_rate/sps, rolloff, span*sps)
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: |
      firdes.root_raised_cosine(1.0, samp_rate, samp_rate/sps, rolloff, span*sps)
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: |
      firdes.root_raised_cosine(1.0, samp_rate, samp_rate/sps, rolloff, span*sps)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Modulation (0 = BPSK, 1 = QPSK, 2 = 8PSK, 3 = 16QAM)
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Class Index
    ymax: '3.5'
    ymin: '-0.5'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [analog_random_source_x_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [analog_random_source_x_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [analog_random_source_x_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0, '0']
- [blocks_selector_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', epy_block_2, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0, '0', interp_fir_filter_xxx_0_0_0_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '1', qtgui_time_sink_x_0, '0']
- [epy_block_0, label_out, blocks_message_debug_0, print]
- [epy_block_1, '0', qtgui_const_sink_x_0, '0']
- [epy_block_1, '1', qtgui_time_sink_x_0, '0']
- [epy_block_1, label_out, blocks_message_debug_0, print]
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_selector_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_selector_0, '1']
- [interp_fir_filter_xxx_0_0_0, '0', blocks_selector_0, '2']
- [interp_fir_filter_xxx_0_0_0_0, '0', blocks_selector_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
